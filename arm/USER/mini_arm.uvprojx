# Keil uVision project mini_arm.uvprojx, settings and files
target STM32F103 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mini_arm_revxx +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\FLASH;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\SDCARD;..\FATFS\src;..\FATFS\exfuns;..\VMALLOC;..\HARDWARE\TIMER;..\HARDWARE\ENC28J60;..\uIP-1.0\uip;..\uIP-1.0\apps\dhcpc;..\uIP-1.0\apps\resolv;..\uIP-1.0\apps\webserver;..\uIP-APP;..\HARDWARE\RTC;..\USB\CONFIG\inc;..\USB\LIB\inc;..\USB\APP;..\MODBUS;..\TCPIP;..\..\bacnet;..\..\bacnet\include;..\..\bacnet\private;..\KEY;..\FILTER;..\..\IO_control;..\..\common;..\..\scan;..\..\SD;..\..\SD\FATFS\exfuns;..\..\SD\FATFS\src;..\FLASH;..\..\key;..\..\display;..\..\SNTP;..\..\RM;..\HARDWARE\EMMC;..\HARDWARE\ESP8266;..\uIP-1.0\apps\smtp;..\uIP-APP;..\..\SD\FATFS_SD;..\..\SD\FATFS_SD\option;..\..\..\Transduce\Transducer2 peressure\MDK-ARM\AMP8408GDT2\Sensor
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x60000
  memory RVCT6: RAM 0x60000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CORE/: cortexm3_macro_rvds.s core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/SDCARD/: MMC_SD.C sdcard.c
    ../HARDWARE/EMMC/: SdioEmmcDrive.c
    ../STM32F10x_FWLib/src/: stm32f10x_sdio.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group UIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group UIP-APP
    ../uIP-APP/: tapdev.c clock-arch.c dyndns.c dyndns_app.c CMIME64.c smtpc.c
    ../uIP-1.0/apps/dhcpc/: dhcpc.c
    ./: tcp_modbus.c udp_scan.c remote_connect.c
    ../TCPIP/: tcpip_task.c
    ../../SNTP/: sntpc.c
    ../uIP-1.0/apps/resolv/: resolv.c
  group bacnet_common
    ../../bacnet/: bac_interface.c bip.c
    ../../../BACLIB/: bacnet_ARM_revXX_mini.lib
  group bacnet_private
    ../../bacnet/private/: alarm.c bac_control.c decode.c MONITOR.C POINT.C ptransfer.c user_data.c
  group io
    ../../IO_control/: io.c IO_control_ARM_revx.lib
  group flash
    ../FLASH/: flash_user.c
  group display
    ../../display/: LCD.c Display.c
  group key
    ../../key/: key.c
  group comm_to_sub
    ../../scan/: commsub.c scan.c
  group common
    ../../common/: info.c modbus.c main.c range.c comm.c pic.c Output.c MINI_revison.TXT
    ./: newtiny.c
  group sd
    ../../SD/FATFS/exfuns/: exfuns.c
    ../../SD/FATFS/src/: diskio.c ff.c
  group arm
    ./: user_arm.c
  group wifi
    ./: wifi.c
    ../HARDWARE/ESP8266/: bsp_esp8266.c
    ../TCPIP/: tcp_debug.c
